# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\MALLOC;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\BEEP;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\USB\USB_APP;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_OTG_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/SRAM/: sram.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_fsmc.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group README
    ../: readme.txt
  group USB_APP
    ../USB/USB_APP/: usb_bsp.c usbd_cdc_vcp.c usbd_desc.c usbd_usr.c
  group USB_DEVICE
    ../USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ../USB/STM32_USB_Device_Library/Class/cdc/src/: usbd_cdc_core.c
  group USB_DRIVER
    ../USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
